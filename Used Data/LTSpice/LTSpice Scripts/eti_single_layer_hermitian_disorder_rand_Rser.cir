*Single layer ETI circuit
C1	(1|1|1|A)	(1|1|1|B)	{disorderfunc(9*(64*TRun+1)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C2	(1|2|1|A)	(1|2|1|B)	{disorderfunc(9*(64*TRun+9)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C3	(1|3|1|A)	(1|3|1|B)	{disorderfunc(9*(64*TRun+17)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C4	(1|4|1|A)	(1|4|1|B)	{disorderfunc(9*(64*TRun+25)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C5	(1|5|1|A)	(1|5|1|B)	{disorderfunc(9*(64*TRun+33)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C6	(1|6|1|A)	(1|6|1|B)	{disorderfunc(9*(64*TRun+41)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C7	(1|7|1|A)	(1|7|1|B)	{disorderfunc(9*(64*TRun+49)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C8	(1|8|1|A)	(1|8|1|B)	{disorderfunc(9*(64*TRun+57)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C9	(2|1|1|A)	(2|1|1|B)	{disorderfunc(9*(64*TRun+2)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C10	(2|2|1|A)	(2|2|1|B)	{disorderfunc(9*(64*TRun+10)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C11	(2|3|1|A)	(2|3|1|B)	{disorderfunc(9*(64*TRun+18)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C12	(2|4|1|A)	(2|4|1|B)	{disorderfunc(9*(64*TRun+26)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C13	(2|5|1|A)	(2|5|1|B)	{disorderfunc(9*(64*TRun+34)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C14	(2|6|1|A)	(2|6|1|B)	{disorderfunc(9*(64*TRun+42)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C15	(2|7|1|A)	(2|7|1|B)	{disorderfunc(9*(64*TRun+50)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C16	(2|8|1|A)	(2|8|1|B)	{disorderfunc(9*(64*TRun+58)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C17	(3|1|1|A)	(3|1|1|B)	{disorderfunc(9*(64*TRun+3)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C18	(3|2|1|A)	(3|2|1|B)	{disorderfunc(9*(64*TRun+11)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C19	(3|3|1|A)	(3|3|1|B)	{disorderfunc(9*(64*TRun+19)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C20	(3|4|1|A)	(3|4|1|B)	{disorderfunc(9*(64*TRun+27)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C21	(3|5|1|A)	(3|5|1|B)	{disorderfunc(9*(64*TRun+35)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C22	(3|6|1|A)	(3|6|1|B)	{disorderfunc(9*(64*TRun+43)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C23	(3|7|1|A)	(3|7|1|B)	{disorderfunc(9*(64*TRun+51)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C24	(3|8|1|A)	(3|8|1|B)	{disorderfunc(9*(64*TRun+59)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C25	(4|1|1|A)	(4|1|1|B)	{disorderfunc(9*(64*TRun+4)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C26	(4|2|1|A)	(4|2|1|B)	{disorderfunc(9*(64*TRun+12)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C27	(4|3|1|A)	(4|3|1|B)	{disorderfunc(9*(64*TRun+20)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C28	(4|4|1|A)	(4|4|1|B)	{disorderfunc(9*(64*TRun+28)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C29	(4|5|1|A)	(4|5|1|B)	{disorderfunc(9*(64*TRun+36)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C30	(4|6|1|A)	(4|6|1|B)	{disorderfunc(9*(64*TRun+44)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C31	(4|7|1|A)	(4|7|1|B)	{disorderfunc(9*(64*TRun+52)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C32	(4|8|1|A)	(4|8|1|B)	{disorderfunc(9*(64*TRun+60)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C33	(5|1|1|A)	(5|1|1|B)	{disorderfunc(9*(64*TRun+5)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C34	(5|2|1|A)	(5|2|1|B)	{disorderfunc(9*(64*TRun+13)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C35	(5|3|1|A)	(5|3|1|B)	{disorderfunc(9*(64*TRun+21)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C36	(5|4|1|A)	(5|4|1|B)	{disorderfunc(9*(64*TRun+29)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C37	(5|5|1|A)	(5|5|1|B)	{disorderfunc(9*(64*TRun+37)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C38	(5|6|1|A)	(5|6|1|B)	{disorderfunc(9*(64*TRun+45)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C39	(5|7|1|A)	(5|7|1|B)	{disorderfunc(9*(64*TRun+53)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C40	(5|8|1|A)	(5|8|1|B)	{disorderfunc(9*(64*TRun+61)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C41	(6|1|1|A)	(6|1|1|B)	{disorderfunc(9*(64*TRun+6)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C42	(6|2|1|A)	(6|2|1|B)	{disorderfunc(9*(64*TRun+14)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C43	(6|3|1|A)	(6|3|1|B)	{disorderfunc(9*(64*TRun+22)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C44	(6|4|1|A)	(6|4|1|B)	{disorderfunc(9*(64*TRun+30)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C45	(6|5|1|A)	(6|5|1|B)	{disorderfunc(9*(64*TRun+38)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C46	(6|6|1|A)	(6|6|1|B)	{disorderfunc(9*(64*TRun+46)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C47	(6|7|1|A)	(6|7|1|B)	{disorderfunc(9*(64*TRun+54)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C48	(6|8|1|A)	(6|8|1|B)	{disorderfunc(9*(64*TRun+62)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C49	(7|1|1|A)	(7|1|1|B)	{disorderfunc(9*(64*TRun+7)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C50	(7|2|1|A)	(7|2|1|B)	{disorderfunc(9*(64*TRun+15)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C51	(7|3|1|A)	(7|3|1|B)	{disorderfunc(9*(64*TRun+23)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C52	(7|4|1|A)	(7|4|1|B)	{disorderfunc(9*(64*TRun+31)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C53	(7|5|1|A)	(7|5|1|B)	{disorderfunc(9*(64*TRun+39)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C54	(7|6|1|A)	(7|6|1|B)	{disorderfunc(9*(64*TRun+47)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C55	(7|7|1|A)	(7|7|1|B)	{disorderfunc(9*(64*TRun+55)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C56	(7|8|1|A)	(7|8|1|B)	{disorderfunc(9*(64*TRun+63)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C57	(8|1|1|A)	(8|1|1|B)	{disorderfunc(9*(64*TRun+8)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C58	(8|2|1|A)	(8|2|1|B)	{disorderfunc(9*(64*TRun+16)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C59	(8|3|1|A)	(8|3|1|B)	{disorderfunc(9*(64*TRun+24)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C60	(8|4|1|A)	(8|4|1|B)	{disorderfunc(9*(64*TRun+32)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C61	(8|5|1|A)	(8|5|1|B)	{disorderfunc(9*(64*TRun+40)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C62	(8|6|1|A)	(8|6|1|B)	{disorderfunc(9*(64*TRun+48)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C63	(8|7|1|A)	(8|7|1|B)	{disorderfunc(9*(64*TRun+56)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C64	(8|8|1|A)	(8|8|1|B)	{disorderfunc(9*(64*TRun+64)+0,C1,tolC1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC1,tolC1)}
C65	(1|1|1|B)	(2|8|1|A)	{disorderfunc(9*(64*TRun+1)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C66	(1|2|1|B)	(2|1|1|A)	{disorderfunc(9*(64*TRun+9)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C67	(1|3|1|B)	(2|2|1|A)	{disorderfunc(9*(64*TRun+17)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C68	(1|4|1|B)	(2|3|1|A)	{disorderfunc(9*(64*TRun+25)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C69	(1|5|1|B)	(2|4|1|A)	{disorderfunc(9*(64*TRun+33)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C70	(1|6|1|B)	(2|5|1|A)	{disorderfunc(9*(64*TRun+41)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C71	(1|7|1|B)	(2|6|1|A)	{disorderfunc(9*(64*TRun+49)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C72	(1|8|1|B)	(2|7|1|A)	{disorderfunc(9*(64*TRun+57)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C73	(2|1|1|B)	(3|8|1|A)	{disorderfunc(9*(64*TRun+2)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C74	(2|2|1|B)	(3|1|1|A)	{disorderfunc(9*(64*TRun+10)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C75	(2|3|1|B)	(3|2|1|A)	{disorderfunc(9*(64*TRun+18)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C76	(2|4|1|B)	(3|3|1|A)	{disorderfunc(9*(64*TRun+26)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C77	(2|5|1|B)	(3|4|1|A)	{disorderfunc(9*(64*TRun+34)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C78	(2|6|1|B)	(3|5|1|A)	{disorderfunc(9*(64*TRun+42)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C79	(2|7|1|B)	(3|6|1|A)	{disorderfunc(9*(64*TRun+50)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C80	(2|8|1|B)	(3|7|1|A)	{disorderfunc(9*(64*TRun+58)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C81	(3|1|1|B)	(4|8|1|A)	{disorderfunc(9*(64*TRun+3)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C82	(3|2|1|B)	(4|1|1|A)	{disorderfunc(9*(64*TRun+11)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C83	(3|3|1|B)	(4|2|1|A)	{disorderfunc(9*(64*TRun+19)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C84	(3|4|1|B)	(4|3|1|A)	{disorderfunc(9*(64*TRun+27)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C85	(3|5|1|B)	(4|4|1|A)	{disorderfunc(9*(64*TRun+35)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C86	(3|6|1|B)	(4|5|1|A)	{disorderfunc(9*(64*TRun+43)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C87	(3|7|1|B)	(4|6|1|A)	{disorderfunc(9*(64*TRun+51)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C88	(3|8|1|B)	(4|7|1|A)	{disorderfunc(9*(64*TRun+59)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C89	(4|1|1|B)	(5|8|1|A)	{disorderfunc(9*(64*TRun+4)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C90	(4|2|1|B)	(5|1|1|A)	{disorderfunc(9*(64*TRun+12)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C91	(4|3|1|B)	(5|2|1|A)	{disorderfunc(9*(64*TRun+20)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C92	(4|4|1|B)	(5|3|1|A)	{disorderfunc(9*(64*TRun+28)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C93	(4|5|1|B)	(5|4|1|A)	{disorderfunc(9*(64*TRun+36)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C94	(4|6|1|B)	(5|5|1|A)	{disorderfunc(9*(64*TRun+44)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C95	(4|7|1|B)	(5|6|1|A)	{disorderfunc(9*(64*TRun+52)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C96	(4|8|1|B)	(5|7|1|A)	{disorderfunc(9*(64*TRun+60)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C97	(5|1|1|B)	(6|8|1|A)	{disorderfunc(9*(64*TRun+5)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C98	(5|2|1|B)	(6|1|1|A)	{disorderfunc(9*(64*TRun+13)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C99	(5|3|1|B)	(6|2|1|A)	{disorderfunc(9*(64*TRun+21)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C100	(5|4|1|B)	(6|3|1|A)	{disorderfunc(9*(64*TRun+29)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C101	(5|5|1|B)	(6|4|1|A)	{disorderfunc(9*(64*TRun+37)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C102	(5|6|1|B)	(6|5|1|A)	{disorderfunc(9*(64*TRun+45)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C103	(5|7|1|B)	(6|6|1|A)	{disorderfunc(9*(64*TRun+53)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C104	(5|8|1|B)	(6|7|1|A)	{disorderfunc(9*(64*TRun+61)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C105	(6|1|1|B)	(7|8|1|A)	{disorderfunc(9*(64*TRun+6)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C106	(6|2|1|B)	(7|1|1|A)	{disorderfunc(9*(64*TRun+14)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C107	(6|3|1|B)	(7|2|1|A)	{disorderfunc(9*(64*TRun+22)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C108	(6|4|1|B)	(7|3|1|A)	{disorderfunc(9*(64*TRun+30)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C109	(6|5|1|B)	(7|4|1|A)	{disorderfunc(9*(64*TRun+38)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C110	(6|6|1|B)	(7|5|1|A)	{disorderfunc(9*(64*TRun+46)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C111	(6|7|1|B)	(7|6|1|A)	{disorderfunc(9*(64*TRun+54)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C112	(6|8|1|B)	(7|7|1|A)	{disorderfunc(9*(64*TRun+62)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C113	(7|1|1|B)	(8|8|1|A)	{disorderfunc(9*(64*TRun+7)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C114	(7|2|1|B)	(8|1|1|A)	{disorderfunc(9*(64*TRun+15)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C115	(7|3|1|B)	(8|2|1|A)	{disorderfunc(9*(64*TRun+23)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C116	(7|4|1|B)	(8|3|1|A)	{disorderfunc(9*(64*TRun+31)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C117	(7|5|1|B)	(8|4|1|A)	{disorderfunc(9*(64*TRun+39)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C118	(7|6|1|B)	(8|5|1|A)	{disorderfunc(9*(64*TRun+47)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C119	(7|7|1|B)	(8|6|1|A)	{disorderfunc(9*(64*TRun+55)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C120	(7|8|1|B)	(8|7|1|A)	{disorderfunc(9*(64*TRun+63)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C121	(8|1|1|B)	(1|8|1|A)	{disorderfunc(9*(64*TRun+8)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C122	(8|2|1|B)	(1|1|1|A)	{disorderfunc(9*(64*TRun+16)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C123	(8|3|1|B)	(1|2|1|A)	{disorderfunc(9*(64*TRun+24)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C124	(8|4|1|B)	(1|3|1|A)	{disorderfunc(9*(64*TRun+32)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C125	(8|5|1|B)	(1|4|1|A)	{disorderfunc(9*(64*TRun+40)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C126	(8|6|1|B)	(1|5|1|A)	{disorderfunc(9*(64*TRun+48)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C127	(8|7|1|B)	(1|6|1|A)	{disorderfunc(9*(64*TRun+56)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C128	(8|8|1|B)	(1|7|1|A)	{disorderfunc(9*(64*TRun+64)+1,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C129	(1|1|1|B)	(8|2|1|A)	{disorderfunc(9*(64*TRun+1)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C130	(1|2|1|B)	(8|3|1|A)	{disorderfunc(9*(64*TRun+9)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C131	(1|3|1|B)	(8|4|1|A)	{disorderfunc(9*(64*TRun+17)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C132	(1|4|1|B)	(8|5|1|A)	{disorderfunc(9*(64*TRun+25)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C133	(1|5|1|B)	(8|6|1|A)	{disorderfunc(9*(64*TRun+33)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C134	(1|6|1|B)	(8|7|1|A)	{disorderfunc(9*(64*TRun+41)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C135	(1|7|1|B)	(8|8|1|A)	{disorderfunc(9*(64*TRun+49)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C136	(1|8|1|B)	(8|1|1|A)	{disorderfunc(9*(64*TRun+57)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C137	(2|1|1|B)	(1|2|1|A)	{disorderfunc(9*(64*TRun+2)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C138	(2|2|1|B)	(1|3|1|A)	{disorderfunc(9*(64*TRun+10)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C139	(2|3|1|B)	(1|4|1|A)	{disorderfunc(9*(64*TRun+18)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C140	(2|4|1|B)	(1|5|1|A)	{disorderfunc(9*(64*TRun+26)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C141	(2|5|1|B)	(1|6|1|A)	{disorderfunc(9*(64*TRun+34)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C142	(2|6|1|B)	(1|7|1|A)	{disorderfunc(9*(64*TRun+42)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C143	(2|7|1|B)	(1|8|1|A)	{disorderfunc(9*(64*TRun+50)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C144	(2|8|1|B)	(1|1|1|A)	{disorderfunc(9*(64*TRun+58)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C145	(3|1|1|B)	(2|2|1|A)	{disorderfunc(9*(64*TRun+3)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C146	(3|2|1|B)	(2|3|1|A)	{disorderfunc(9*(64*TRun+11)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C147	(3|3|1|B)	(2|4|1|A)	{disorderfunc(9*(64*TRun+19)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C148	(3|4|1|B)	(2|5|1|A)	{disorderfunc(9*(64*TRun+27)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C149	(3|5|1|B)	(2|6|1|A)	{disorderfunc(9*(64*TRun+35)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C150	(3|6|1|B)	(2|7|1|A)	{disorderfunc(9*(64*TRun+43)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C151	(3|7|1|B)	(2|8|1|A)	{disorderfunc(9*(64*TRun+51)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C152	(3|8|1|B)	(2|1|1|A)	{disorderfunc(9*(64*TRun+59)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C153	(4|1|1|B)	(3|2|1|A)	{disorderfunc(9*(64*TRun+4)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C154	(4|2|1|B)	(3|3|1|A)	{disorderfunc(9*(64*TRun+12)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C155	(4|3|1|B)	(3|4|1|A)	{disorderfunc(9*(64*TRun+20)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C156	(4|4|1|B)	(3|5|1|A)	{disorderfunc(9*(64*TRun+28)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C157	(4|5|1|B)	(3|6|1|A)	{disorderfunc(9*(64*TRun+36)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C158	(4|6|1|B)	(3|7|1|A)	{disorderfunc(9*(64*TRun+44)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C159	(4|7|1|B)	(3|8|1|A)	{disorderfunc(9*(64*TRun+52)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C160	(4|8|1|B)	(3|1|1|A)	{disorderfunc(9*(64*TRun+60)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C161	(5|1|1|B)	(4|2|1|A)	{disorderfunc(9*(64*TRun+5)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C162	(5|2|1|B)	(4|3|1|A)	{disorderfunc(9*(64*TRun+13)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C163	(5|3|1|B)	(4|4|1|A)	{disorderfunc(9*(64*TRun+21)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C164	(5|4|1|B)	(4|5|1|A)	{disorderfunc(9*(64*TRun+29)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C165	(5|5|1|B)	(4|6|1|A)	{disorderfunc(9*(64*TRun+37)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C166	(5|6|1|B)	(4|7|1|A)	{disorderfunc(9*(64*TRun+45)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C167	(5|7|1|B)	(4|8|1|A)	{disorderfunc(9*(64*TRun+53)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C168	(5|8|1|B)	(4|1|1|A)	{disorderfunc(9*(64*TRun+61)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C169	(6|1|1|B)	(5|2|1|A)	{disorderfunc(9*(64*TRun+6)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C170	(6|2|1|B)	(5|3|1|A)	{disorderfunc(9*(64*TRun+14)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C171	(6|3|1|B)	(5|4|1|A)	{disorderfunc(9*(64*TRun+22)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C172	(6|4|1|B)	(5|5|1|A)	{disorderfunc(9*(64*TRun+30)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C173	(6|5|1|B)	(5|6|1|A)	{disorderfunc(9*(64*TRun+38)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C174	(6|6|1|B)	(5|7|1|A)	{disorderfunc(9*(64*TRun+46)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C175	(6|7|1|B)	(5|8|1|A)	{disorderfunc(9*(64*TRun+54)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C176	(6|8|1|B)	(5|1|1|A)	{disorderfunc(9*(64*TRun+62)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C177	(7|1|1|B)	(6|2|1|A)	{disorderfunc(9*(64*TRun+7)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C178	(7|2|1|B)	(6|3|1|A)	{disorderfunc(9*(64*TRun+15)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C179	(7|3|1|B)	(6|4|1|A)	{disorderfunc(9*(64*TRun+23)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C180	(7|4|1|B)	(6|5|1|A)	{disorderfunc(9*(64*TRun+31)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C181	(7|5|1|B)	(6|6|1|A)	{disorderfunc(9*(64*TRun+39)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C182	(7|6|1|B)	(6|7|1|A)	{disorderfunc(9*(64*TRun+47)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C183	(7|7|1|B)	(6|8|1|A)	{disorderfunc(9*(64*TRun+55)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C184	(7|8|1|B)	(6|1|1|A)	{disorderfunc(9*(64*TRun+63)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C185	(8|1|1|B)	(7|2|1|A)	{disorderfunc(9*(64*TRun+8)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C186	(8|2|1|B)	(7|3|1|A)	{disorderfunc(9*(64*TRun+16)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C187	(8|3|1|B)	(7|4|1|A)	{disorderfunc(9*(64*TRun+24)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C188	(8|4|1|B)	(7|5|1|A)	{disorderfunc(9*(64*TRun+32)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C189	(8|5|1|B)	(7|6|1|A)	{disorderfunc(9*(64*TRun+40)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C190	(8|6|1|B)	(7|7|1|A)	{disorderfunc(9*(64*TRun+48)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C191	(8|7|1|B)	(7|8|1|A)	{disorderfunc(9*(64*TRun+56)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C192	(8|8|1|B)	(7|1|1|A)	{disorderfunc(9*(64*TRun+64)+2,C2,tolC2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC2,tolC2)}
C193	(1|1|1|A)	(1|2|1|A)	{disorderfunc(9*(64*TRun+1)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C194	(1|2|1|A)	(1|3|1|A)	{disorderfunc(9*(64*TRun+9)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C195	(1|3|1|A)	(1|4|1|A)	{disorderfunc(9*(64*TRun+17)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C196	(1|4|1|A)	(1|5|1|A)	{disorderfunc(9*(64*TRun+25)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C197	(1|5|1|A)	(1|6|1|A)	{disorderfunc(9*(64*TRun+33)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C198	(1|6|1|A)	(1|7|1|A)	{disorderfunc(9*(64*TRun+41)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C199	(1|7|1|A)	(1|8|1|A)	{disorderfunc(9*(64*TRun+49)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C200	(1|8|1|A)	(1|1|1|A)	{disorderfunc(9*(64*TRun+57)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C201	(2|1|1|A)	(2|2|1|A)	{disorderfunc(9*(64*TRun+2)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C202	(2|2|1|A)	(2|3|1|A)	{disorderfunc(9*(64*TRun+10)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C203	(2|3|1|A)	(2|4|1|A)	{disorderfunc(9*(64*TRun+18)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C204	(2|4|1|A)	(2|5|1|A)	{disorderfunc(9*(64*TRun+26)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C205	(2|5|1|A)	(2|6|1|A)	{disorderfunc(9*(64*TRun+34)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C206	(2|6|1|A)	(2|7|1|A)	{disorderfunc(9*(64*TRun+42)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C207	(2|7|1|A)	(2|8|1|A)	{disorderfunc(9*(64*TRun+50)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C208	(2|8|1|A)	(2|1|1|A)	{disorderfunc(9*(64*TRun+58)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C209	(3|1|1|A)	(3|2|1|A)	{disorderfunc(9*(64*TRun+3)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C210	(3|2|1|A)	(3|3|1|A)	{disorderfunc(9*(64*TRun+11)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C211	(3|3|1|A)	(3|4|1|A)	{disorderfunc(9*(64*TRun+19)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C212	(3|4|1|A)	(3|5|1|A)	{disorderfunc(9*(64*TRun+27)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C213	(3|5|1|A)	(3|6|1|A)	{disorderfunc(9*(64*TRun+35)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C214	(3|6|1|A)	(3|7|1|A)	{disorderfunc(9*(64*TRun+43)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C215	(3|7|1|A)	(3|8|1|A)	{disorderfunc(9*(64*TRun+51)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C216	(3|8|1|A)	(3|1|1|A)	{disorderfunc(9*(64*TRun+59)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C217	(4|1|1|A)	(4|2|1|A)	{disorderfunc(9*(64*TRun+4)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C218	(4|2|1|A)	(4|3|1|A)	{disorderfunc(9*(64*TRun+12)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C219	(4|3|1|A)	(4|4|1|A)	{disorderfunc(9*(64*TRun+20)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C220	(4|4|1|A)	(4|5|1|A)	{disorderfunc(9*(64*TRun+28)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C221	(4|5|1|A)	(4|6|1|A)	{disorderfunc(9*(64*TRun+36)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C222	(4|6|1|A)	(4|7|1|A)	{disorderfunc(9*(64*TRun+44)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C223	(4|7|1|A)	(4|8|1|A)	{disorderfunc(9*(64*TRun+52)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C224	(4|8|1|A)	(4|1|1|A)	{disorderfunc(9*(64*TRun+60)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C225	(5|1|1|A)	(5|2|1|A)	{disorderfunc(9*(64*TRun+5)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C226	(5|2|1|A)	(5|3|1|A)	{disorderfunc(9*(64*TRun+13)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C227	(5|3|1|A)	(5|4|1|A)	{disorderfunc(9*(64*TRun+21)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C228	(5|4|1|A)	(5|5|1|A)	{disorderfunc(9*(64*TRun+29)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C229	(5|5|1|A)	(5|6|1|A)	{disorderfunc(9*(64*TRun+37)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C230	(5|6|1|A)	(5|7|1|A)	{disorderfunc(9*(64*TRun+45)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C231	(5|7|1|A)	(5|8|1|A)	{disorderfunc(9*(64*TRun+53)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C232	(5|8|1|A)	(5|1|1|A)	{disorderfunc(9*(64*TRun+61)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C233	(6|1|1|A)	(6|2|1|A)	{disorderfunc(9*(64*TRun+6)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C234	(6|2|1|A)	(6|3|1|A)	{disorderfunc(9*(64*TRun+14)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C235	(6|3|1|A)	(6|4|1|A)	{disorderfunc(9*(64*TRun+22)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C236	(6|4|1|A)	(6|5|1|A)	{disorderfunc(9*(64*TRun+30)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C237	(6|5|1|A)	(6|6|1|A)	{disorderfunc(9*(64*TRun+38)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C238	(6|6|1|A)	(6|7|1|A)	{disorderfunc(9*(64*TRun+46)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C239	(6|7|1|A)	(6|8|1|A)	{disorderfunc(9*(64*TRun+54)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C240	(6|8|1|A)	(6|1|1|A)	{disorderfunc(9*(64*TRun+62)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C241	(7|1|1|A)	(7|2|1|A)	{disorderfunc(9*(64*TRun+7)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C242	(7|2|1|A)	(7|3|1|A)	{disorderfunc(9*(64*TRun+15)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C243	(7|3|1|A)	(7|4|1|A)	{disorderfunc(9*(64*TRun+23)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C244	(7|4|1|A)	(7|5|1|A)	{disorderfunc(9*(64*TRun+31)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C245	(7|5|1|A)	(7|6|1|A)	{disorderfunc(9*(64*TRun+39)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C246	(7|6|1|A)	(7|7|1|A)	{disorderfunc(9*(64*TRun+47)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C247	(7|7|1|A)	(7|8|1|A)	{disorderfunc(9*(64*TRun+55)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C248	(7|8|1|A)	(7|1|1|A)	{disorderfunc(9*(64*TRun+63)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C249	(8|1|1|A)	(8|2|1|A)	{disorderfunc(9*(64*TRun+8)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C250	(8|2|1|A)	(8|3|1|A)	{disorderfunc(9*(64*TRun+16)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C251	(8|3|1|A)	(8|4|1|A)	{disorderfunc(9*(64*TRun+24)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C252	(8|4|1|A)	(8|5|1|A)	{disorderfunc(9*(64*TRun+32)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C253	(8|5|1|A)	(8|6|1|A)	{disorderfunc(9*(64*TRun+40)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C254	(8|6|1|A)	(8|7|1|A)	{disorderfunc(9*(64*TRun+48)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C255	(8|7|1|A)	(8|8|1|A)	{disorderfunc(9*(64*TRun+56)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
C256	(8|8|1|A)	(8|1|1|A)	{disorderfunc(9*(64*TRun+64)+3,C3,tolC3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserC3,tolC3)}
L1	(1|1|1|B)	(1|2|1|B)	{disorderfunc(9*(64*TRun+1)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L2	(1|2|1|B)	(1|3|1|B)	{disorderfunc(9*(64*TRun+9)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L3	(1|3|1|B)	(1|4|1|B)	{disorderfunc(9*(64*TRun+17)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L4	(1|4|1|B)	(1|5|1|B)	{disorderfunc(9*(64*TRun+25)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L5	(1|5|1|B)	(1|6|1|B)	{disorderfunc(9*(64*TRun+33)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L6	(1|6|1|B)	(1|7|1|B)	{disorderfunc(9*(64*TRun+41)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L7	(1|7|1|B)	(1|8|1|B)	{disorderfunc(9*(64*TRun+49)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L8	(1|8|1|B)	(1|1|1|B)	{disorderfunc(9*(64*TRun+57)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L9	(2|1|1|B)	(2|2|1|B)	{disorderfunc(9*(64*TRun+2)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L10	(2|2|1|B)	(2|3|1|B)	{disorderfunc(9*(64*TRun+10)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L11	(2|3|1|B)	(2|4|1|B)	{disorderfunc(9*(64*TRun+18)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L12	(2|4|1|B)	(2|5|1|B)	{disorderfunc(9*(64*TRun+26)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L13	(2|5|1|B)	(2|6|1|B)	{disorderfunc(9*(64*TRun+34)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L14	(2|6|1|B)	(2|7|1|B)	{disorderfunc(9*(64*TRun+42)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L15	(2|7|1|B)	(2|8|1|B)	{disorderfunc(9*(64*TRun+50)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L16	(2|8|1|B)	(2|1|1|B)	{disorderfunc(9*(64*TRun+58)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L17	(3|1|1|B)	(3|2|1|B)	{disorderfunc(9*(64*TRun+3)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L18	(3|2|1|B)	(3|3|1|B)	{disorderfunc(9*(64*TRun+11)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L19	(3|3|1|B)	(3|4|1|B)	{disorderfunc(9*(64*TRun+19)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L20	(3|4|1|B)	(3|5|1|B)	{disorderfunc(9*(64*TRun+27)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L21	(3|5|1|B)	(3|6|1|B)	{disorderfunc(9*(64*TRun+35)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L22	(3|6|1|B)	(3|7|1|B)	{disorderfunc(9*(64*TRun+43)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L23	(3|7|1|B)	(3|8|1|B)	{disorderfunc(9*(64*TRun+51)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L24	(3|8|1|B)	(3|1|1|B)	{disorderfunc(9*(64*TRun+59)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L25	(4|1|1|B)	(4|2|1|B)	{disorderfunc(9*(64*TRun+4)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L26	(4|2|1|B)	(4|3|1|B)	{disorderfunc(9*(64*TRun+12)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L27	(4|3|1|B)	(4|4|1|B)	{disorderfunc(9*(64*TRun+20)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L28	(4|4|1|B)	(4|5|1|B)	{disorderfunc(9*(64*TRun+28)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L29	(4|5|1|B)	(4|6|1|B)	{disorderfunc(9*(64*TRun+36)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L30	(4|6|1|B)	(4|7|1|B)	{disorderfunc(9*(64*TRun+44)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L31	(4|7|1|B)	(4|8|1|B)	{disorderfunc(9*(64*TRun+52)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L32	(4|8|1|B)	(4|1|1|B)	{disorderfunc(9*(64*TRun+60)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L33	(5|1|1|B)	(5|2|1|B)	{disorderfunc(9*(64*TRun+5)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L34	(5|2|1|B)	(5|3|1|B)	{disorderfunc(9*(64*TRun+13)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L35	(5|3|1|B)	(5|4|1|B)	{disorderfunc(9*(64*TRun+21)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L36	(5|4|1|B)	(5|5|1|B)	{disorderfunc(9*(64*TRun+29)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L37	(5|5|1|B)	(5|6|1|B)	{disorderfunc(9*(64*TRun+37)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L38	(5|6|1|B)	(5|7|1|B)	{disorderfunc(9*(64*TRun+45)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L39	(5|7|1|B)	(5|8|1|B)	{disorderfunc(9*(64*TRun+53)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L40	(5|8|1|B)	(5|1|1|B)	{disorderfunc(9*(64*TRun+61)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L41	(6|1|1|B)	(6|2|1|B)	{disorderfunc(9*(64*TRun+6)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L42	(6|2|1|B)	(6|3|1|B)	{disorderfunc(9*(64*TRun+14)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L43	(6|3|1|B)	(6|4|1|B)	{disorderfunc(9*(64*TRun+22)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L44	(6|4|1|B)	(6|5|1|B)	{disorderfunc(9*(64*TRun+30)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L45	(6|5|1|B)	(6|6|1|B)	{disorderfunc(9*(64*TRun+38)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L46	(6|6|1|B)	(6|7|1|B)	{disorderfunc(9*(64*TRun+46)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L47	(6|7|1|B)	(6|8|1|B)	{disorderfunc(9*(64*TRun+54)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L48	(6|8|1|B)	(6|1|1|B)	{disorderfunc(9*(64*TRun+62)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L49	(7|1|1|B)	(7|2|1|B)	{disorderfunc(9*(64*TRun+7)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L50	(7|2|1|B)	(7|3|1|B)	{disorderfunc(9*(64*TRun+15)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L51	(7|3|1|B)	(7|4|1|B)	{disorderfunc(9*(64*TRun+23)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L52	(7|4|1|B)	(7|5|1|B)	{disorderfunc(9*(64*TRun+31)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L53	(7|5|1|B)	(7|6|1|B)	{disorderfunc(9*(64*TRun+39)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L54	(7|6|1|B)	(7|7|1|B)	{disorderfunc(9*(64*TRun+47)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L55	(7|7|1|B)	(7|8|1|B)	{disorderfunc(9*(64*TRun+55)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L56	(7|8|1|B)	(7|1|1|B)	{disorderfunc(9*(64*TRun+63)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L57	(8|1|1|B)	(8|2|1|B)	{disorderfunc(9*(64*TRun+8)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L58	(8|2|1|B)	(8|3|1|B)	{disorderfunc(9*(64*TRun+16)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L59	(8|3|1|B)	(8|4|1|B)	{disorderfunc(9*(64*TRun+24)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L60	(8|4|1|B)	(8|5|1|B)	{disorderfunc(9*(64*TRun+32)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L61	(8|5|1|B)	(8|6|1|B)	{disorderfunc(9*(64*TRun+40)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L62	(8|6|1|B)	(8|7|1|B)	{disorderfunc(9*(64*TRun+48)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L63	(8|7|1|B)	(8|8|1|B)	{disorderfunc(9*(64*TRun+56)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L64	(8|8|1|B)	(8|1|1|B)	{disorderfunc(9*(64*TRun+64)+4,L1,tolL1)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL1,tolL1)}
L65	(1|1|1|A)	0		{disorderfunc(9*(64*TRun+1)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L66	(1|2|1|A)	0		{disorderfunc(9*(64*TRun+9)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L67	(1|3|1|A)	0		{disorderfunc(9*(64*TRun+17)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L68	(1|4|1|A)	0		{disorderfunc(9*(64*TRun+25)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L69	(1|5|1|A)	0		{disorderfunc(9*(64*TRun+33)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L70	(1|6|1|A)	0		{disorderfunc(9*(64*TRun+41)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L71	(1|7|1|A)	0		{disorderfunc(9*(64*TRun+49)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L72	(1|8|1|A)	0		{disorderfunc(9*(64*TRun+57)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L73	(2|1|1|A)	0		{disorderfunc(9*(64*TRun+2)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L74	(2|2|1|A)	0		{disorderfunc(9*(64*TRun+10)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L75	(2|3|1|A)	0		{disorderfunc(9*(64*TRun+18)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L76	(2|4|1|A)	0		{disorderfunc(9*(64*TRun+26)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L77	(2|5|1|A)	0		{disorderfunc(9*(64*TRun+34)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L78	(2|6|1|A)	0		{disorderfunc(9*(64*TRun+42)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L79	(2|7|1|A)	0		{disorderfunc(9*(64*TRun+50)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L80	(2|8|1|A)	0		{disorderfunc(9*(64*TRun+58)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L81	(3|1|1|A)	0		{disorderfunc(9*(64*TRun+3)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L82	(3|2|1|A)	0		{disorderfunc(9*(64*TRun+11)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L83	(3|3|1|A)	0		{disorderfunc(9*(64*TRun+19)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L84	(3|4|1|A)	0		{disorderfunc(9*(64*TRun+27)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L85	(3|5|1|A)	0		{disorderfunc(9*(64*TRun+35)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L86	(3|6|1|A)	0		{disorderfunc(9*(64*TRun+43)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L87	(3|7|1|A)	0		{disorderfunc(9*(64*TRun+51)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L88	(3|8|1|A)	0		{disorderfunc(9*(64*TRun+59)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L89	(4|1|1|A)	0		{disorderfunc(9*(64*TRun+4)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L90	(4|2|1|A)	0		{disorderfunc(9*(64*TRun+12)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L91	(4|3|1|A)	0		{disorderfunc(9*(64*TRun+20)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L92	(4|4|1|A)	0		{disorderfunc(9*(64*TRun+28)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L93	(4|5|1|A)	0		{disorderfunc(9*(64*TRun+36)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L94	(4|6|1|A)	0		{disorderfunc(9*(64*TRun+44)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L95	(4|7|1|A)	0		{disorderfunc(9*(64*TRun+52)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L96	(4|8|1|A)	0		{disorderfunc(9*(64*TRun+60)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L97	(5|1|1|A)	0		{disorderfunc(9*(64*TRun+5)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L98	(5|2|1|A)	0		{disorderfunc(9*(64*TRun+13)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L99	(5|3|1|A)	0		{disorderfunc(9*(64*TRun+21)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L100	(5|4|1|A)	0		{disorderfunc(9*(64*TRun+29)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L101	(5|5|1|A)	0		{disorderfunc(9*(64*TRun+37)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L102	(5|6|1|A)	0		{disorderfunc(9*(64*TRun+45)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L103	(5|7|1|A)	0		{disorderfunc(9*(64*TRun+53)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L104	(5|8|1|A)	0		{disorderfunc(9*(64*TRun+61)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L105	(6|1|1|A)	0		{disorderfunc(9*(64*TRun+6)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L106	(6|2|1|A)	0		{disorderfunc(9*(64*TRun+14)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L107	(6|3|1|A)	0		{disorderfunc(9*(64*TRun+22)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L108	(6|4|1|A)	0		{disorderfunc(9*(64*TRun+30)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L109	(6|5|1|A)	0		{disorderfunc(9*(64*TRun+38)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L110	(6|6|1|A)	0		{disorderfunc(9*(64*TRun+46)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L111	(6|7|1|A)	0		{disorderfunc(9*(64*TRun+54)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L112	(6|8|1|A)	0		{disorderfunc(9*(64*TRun+62)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L113	(7|1|1|A)	0		{disorderfunc(9*(64*TRun+7)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L114	(7|2|1|A)	0		{disorderfunc(9*(64*TRun+15)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L115	(7|3|1|A)	0		{disorderfunc(9*(64*TRun+23)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L116	(7|4|1|A)	0		{disorderfunc(9*(64*TRun+31)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L117	(7|5|1|A)	0		{disorderfunc(9*(64*TRun+39)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L118	(7|6|1|A)	0		{disorderfunc(9*(64*TRun+47)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L119	(7|7|1|A)	0		{disorderfunc(9*(64*TRun+55)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L120	(7|8|1|A)	0		{disorderfunc(9*(64*TRun+63)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L121	(8|1|1|A)	0		{disorderfunc(9*(64*TRun+8)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L122	(8|2|1|A)	0		{disorderfunc(9*(64*TRun+16)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L123	(8|3|1|A)	0		{disorderfunc(9*(64*TRun+24)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L124	(8|4|1|A)	0		{disorderfunc(9*(64*TRun+32)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L125	(8|5|1|A)	0		{disorderfunc(9*(64*TRun+40)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L126	(8|6|1|A)	0		{disorderfunc(9*(64*TRun+48)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L127	(8|7|1|A)	0		{disorderfunc(9*(64*TRun+56)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L128	(8|8|1|A)	0		{disorderfunc(9*(64*TRun+64)+7,L2,tolL2)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL2,tolL2)}
L129	(1|1|1|B)	0		{disorderfunc(9*(64*TRun+1)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L130	(1|2|1|B)	0		{disorderfunc(9*(64*TRun+9)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L131	(1|3|1|B)	0		{disorderfunc(9*(64*TRun+17)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L132	(1|4|1|B)	0		{disorderfunc(9*(64*TRun+25)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L133	(1|5|1|B)	0		{disorderfunc(9*(64*TRun+33)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L134	(1|6|1|B)	0		{disorderfunc(9*(64*TRun+41)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L135	(1|7|1|B)	0		{disorderfunc(9*(64*TRun+49)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L136	(1|8|1|B)	0		{disorderfunc(9*(64*TRun+57)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L137	(2|1|1|B)	0		{disorderfunc(9*(64*TRun+2)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L138	(2|2|1|B)	0		{disorderfunc(9*(64*TRun+10)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L139	(2|3|1|B)	0		{disorderfunc(9*(64*TRun+18)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L140	(2|4|1|B)	0		{disorderfunc(9*(64*TRun+26)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L141	(2|5|1|B)	0		{disorderfunc(9*(64*TRun+34)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L142	(2|6|1|B)	0		{disorderfunc(9*(64*TRun+42)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L143	(2|7|1|B)	0		{disorderfunc(9*(64*TRun+50)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L144	(2|8|1|B)	0		{disorderfunc(9*(64*TRun+58)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L145	(3|1|1|B)	0		{disorderfunc(9*(64*TRun+3)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L146	(3|2|1|B)	0		{disorderfunc(9*(64*TRun+11)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L147	(3|3|1|B)	0		{disorderfunc(9*(64*TRun+19)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L148	(3|4|1|B)	0		{disorderfunc(9*(64*TRun+27)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L149	(3|5|1|B)	0		{disorderfunc(9*(64*TRun+35)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L150	(3|6|1|B)	0		{disorderfunc(9*(64*TRun+43)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L151	(3|7|1|B)	0		{disorderfunc(9*(64*TRun+51)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L152	(3|8|1|B)	0		{disorderfunc(9*(64*TRun+59)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L153	(4|1|1|B)	0		{disorderfunc(9*(64*TRun+4)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L154	(4|2|1|B)	0		{disorderfunc(9*(64*TRun+12)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L155	(4|3|1|B)	0		{disorderfunc(9*(64*TRun+20)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L156	(4|4|1|B)	0		{disorderfunc(9*(64*TRun+28)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L157	(4|5|1|B)	0		{disorderfunc(9*(64*TRun+36)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L158	(4|6|1|B)	0		{disorderfunc(9*(64*TRun+44)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L159	(4|7|1|B)	0		{disorderfunc(9*(64*TRun+52)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L160	(4|8|1|B)	0		{disorderfunc(9*(64*TRun+60)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L161	(5|1|1|B)	0		{disorderfunc(9*(64*TRun+5)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L162	(5|2|1|B)	0		{disorderfunc(9*(64*TRun+13)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L163	(5|3|1|B)	0		{disorderfunc(9*(64*TRun+21)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L164	(5|4|1|B)	0		{disorderfunc(9*(64*TRun+29)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L165	(5|5|1|B)	0		{disorderfunc(9*(64*TRun+37)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L166	(5|6|1|B)	0		{disorderfunc(9*(64*TRun+45)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L167	(5|7|1|B)	0		{disorderfunc(9*(64*TRun+53)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L168	(5|8|1|B)	0		{disorderfunc(9*(64*TRun+61)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L169	(6|1|1|B)	0		{disorderfunc(9*(64*TRun+6)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L170	(6|2|1|B)	0		{disorderfunc(9*(64*TRun+14)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L171	(6|3|1|B)	0		{disorderfunc(9*(64*TRun+22)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L172	(6|4|1|B)	0		{disorderfunc(9*(64*TRun+30)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L173	(6|5|1|B)	0		{disorderfunc(9*(64*TRun+38)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L174	(6|6|1|B)	0		{disorderfunc(9*(64*TRun+46)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L175	(6|7|1|B)	0		{disorderfunc(9*(64*TRun+54)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L176	(6|8|1|B)	0		{disorderfunc(9*(64*TRun+62)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L177	(7|1|1|B)	0		{disorderfunc(9*(64*TRun+7)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L178	(7|2|1|B)	0		{disorderfunc(9*(64*TRun+15)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L179	(7|3|1|B)	0		{disorderfunc(9*(64*TRun+23)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L180	(7|4|1|B)	0		{disorderfunc(9*(64*TRun+31)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L181	(7|5|1|B)	0		{disorderfunc(9*(64*TRun+39)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L182	(7|6|1|B)	0		{disorderfunc(9*(64*TRun+47)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L183	(7|7|1|B)	0		{disorderfunc(9*(64*TRun+55)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L184	(7|8|1|B)	0		{disorderfunc(9*(64*TRun+63)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L185	(8|1|1|B)	0		{disorderfunc(9*(64*TRun+8)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L186	(8|2|1|B)	0		{disorderfunc(9*(64*TRun+16)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L187	(8|3|1|B)	0		{disorderfunc(9*(64*TRun+24)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L188	(8|4|1|B)	0		{disorderfunc(9*(64*TRun+32)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L189	(8|5|1|B)	0		{disorderfunc(9*(64*TRun+40)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L190	(8|6|1|B)	0		{disorderfunc(9*(64*TRun+48)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L191	(8|7|1|B)	0		{disorderfunc(9*(64*TRun+56)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}
L192	(8|8|1|B)	0		{disorderfunc(9*(64*TRun+64)+8,L3,tolL3)} Rser = {Disorderfunc(9*(64*TRun+1)+0,RserL3,tolL3)}

V1 vol1 0 AC 1
R129 vol1 (1|1|1|B) {Rvolt}
.func disorderfunc(x,y0,dy){y0*(1+dy*(2*rand(x)-1))}
.param TRun = 1
.param   C1 = 150p   RserC1 = 10m   C2 = 75p   RserC2 = 10m   C3 = 150p   RserC3 = 10m   L1 = 27u   RserL1 = 2800m   L2 = 5.6u   RserL2 = 600m   L3 = 27u   RserL3 = 2800m
.param Rvolt = 50
.param   tolC1 = 0.01   tolC2 = 0.01   tolC3 = 0.01   tolL1 = 0.01   tolL2 = 0.05   tolL3 = 0.01
.ac lin 1000 100000 10000000
.save I(R129) V(1|1|1|A) V(1|1|1|B) V(2|1|1|A) V(2|1|1|B) V(3|1|1|A) V(3|1|1|B) V(4|1|1|A) V(4|1|1|B) V(5|1|1|A) V(5|1|1|B) V(6|1|1|A) V(6|1|1|B) V(7|1|1|A) V(7|1|1|B) V(8|1|1|A) V(8|1|1|B) V(1|2|1|A) V(1|2|1|B) V(2|2|1|A) V(2|2|1|B) V(3|2|1|A) V(3|2|1|B) V(4|2|1|A) V(4|2|1|B) V(5|2|1|A) V(5|2|1|B) V(6|2|1|A) V(6|2|1|B) V(7|2|1|A) V(7|2|1|B) V(8|2|1|A) V(8|2|1|B) V(1|3|1|A) V(1|3|1|B) V(2|3|1|A) V(2|3|1|B) V(3|3|1|A) V(3|3|1|B) V(4|3|1|A) V(4|3|1|B) V(5|3|1|A) V(5|3|1|B) V(6|3|1|A) V(6|3|1|B) V(7|3|1|A) V(7|3|1|B) V(8|3|1|A) V(8|3|1|B) V(1|4|1|A) V(1|4|1|B) V(2|4|1|A) V(2|4|1|B) V(3|4|1|A) V(3|4|1|B) V(4|4|1|A) V(4|4|1|B) V(5|4|1|A) V(5|4|1|B) V(6|4|1|A) V(6|4|1|B) V(7|4|1|A) V(7|4|1|B) V(8|4|1|A) V(8|4|1|B) V(1|5|1|A) V(1|5|1|B) V(2|5|1|A) V(2|5|1|B) V(3|5|1|A) V(3|5|1|B) V(4|5|1|A) V(4|5|1|B) V(5|5|1|A) V(5|5|1|B) V(6|5|1|A) V(6|5|1|B) V(7|5|1|A) V(7|5|1|B) V(8|5|1|A) V(8|5|1|B) V(1|6|1|A) V(1|6|1|B) V(2|6|1|A) V(2|6|1|B) V(3|6|1|A) V(3|6|1|B) V(4|6|1|A) V(4|6|1|B) V(5|6|1|A) V(5|6|1|B) V(6|6|1|A) V(6|6|1|B) V(7|6|1|A) V(7|6|1|B) V(8|6|1|A) V(8|6|1|B) V(1|7|1|A) V(1|7|1|B) V(2|7|1|A) V(2|7|1|B) V(3|7|1|A) V(3|7|1|B) V(4|7|1|A) V(4|7|1|B) V(5|7|1|A) V(5|7|1|B) V(6|7|1|A) V(6|7|1|B) V(7|7|1|A) V(7|7|1|B) V(8|7|1|A) V(8|7|1|B) V(1|8|1|A) V(1|8|1|B) V(2|8|1|A) V(2|8|1|B) V(3|8|1|A) V(3|8|1|B) V(4|8|1|A) V(4|8|1|B) V(5|8|1|A) V(5|8|1|B) V(6|8|1|A) V(6|8|1|B) V(7|8|1|A) V(7|8|1|B) V(8|8|1|A) V(8|8|1|B)
