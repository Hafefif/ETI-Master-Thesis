*Single layer ETI circuit
C1	(1|1|1|A)	(1|1|1|B)	{C1} Rser = {RserC1}
C2	(1|2|1|A)	(1|2|1|B)	{C1} Rser = {RserC1}
C3	(1|3|1|A)	(1|3|1|B)	{C1} Rser = {RserC1}
C4	(1|4|1|A)	(1|4|1|B)	{C1} Rser = {RserC1}
C5	(1|5|1|A)	(1|5|1|B)	{C1} Rser = {RserC1}
C6	(1|6|1|A)	(1|6|1|B)	{C1} Rser = {RserC1}
C7	(1|7|1|A)	(1|7|1|B)	{C1} Rser = {RserC1}
C8	(1|8|1|A)	(1|8|1|B)	{C1} Rser = {RserC1}
C9	(2|1|1|A)	(2|1|1|B)	{C1} Rser = {RserC1}
C10	(2|2|1|A)	(2|2|1|B)	{C1} Rser = {RserC1}
C11	(2|3|1|A)	(2|3|1|B)	{C1} Rser = {RserC1}
C12	(2|4|1|A)	(2|4|1|B)	{C1} Rser = {RserC1}
C13	(2|5|1|A)	(2|5|1|B)	{C1} Rser = {RserC1}
C14	(2|6|1|A)	(2|6|1|B)	{C1} Rser = {RserC1}
C15	(2|7|1|A)	(2|7|1|B)	{C1} Rser = {RserC1}
C16	(2|8|1|A)	(2|8|1|B)	{C1} Rser = {RserC1}
C17	(3|1|1|A)	(3|1|1|B)	{C1} Rser = {RserC1}
C18	(3|2|1|A)	(3|2|1|B)	{C1} Rser = {RserC1}
C19	(3|3|1|A)	(3|3|1|B)	{C1} Rser = {RserC1}
C20	(3|4|1|A)	(3|4|1|B)	{C1} Rser = {RserC1}
C21	(3|5|1|A)	(3|5|1|B)	{C1} Rser = {RserC1}
C22	(3|6|1|A)	(3|6|1|B)	{C1} Rser = {RserC1}
C23	(3|7|1|A)	(3|7|1|B)	{C1} Rser = {RserC1}
C24	(3|8|1|A)	(3|8|1|B)	{C1} Rser = {RserC1}
C25	(4|1|1|A)	(4|1|1|B)	{C1} Rser = {RserC1}
C26	(4|2|1|A)	(4|2|1|B)	{C1} Rser = {RserC1}
C27	(4|3|1|A)	(4|3|1|B)	{C1} Rser = {RserC1}
C28	(4|4|1|A)	(4|4|1|B)	{C1} Rser = {RserC1}
C29	(4|5|1|A)	(4|5|1|B)	{C1} Rser = {RserC1}
C30	(4|6|1|A)	(4|6|1|B)	{C1} Rser = {RserC1}
C31	(4|7|1|A)	(4|7|1|B)	{C1} Rser = {RserC1}
C32	(4|8|1|A)	(4|8|1|B)	{C1} Rser = {RserC1}
C33	(5|1|1|A)	(5|1|1|B)	{C1} Rser = {RserC1}
C34	(5|2|1|A)	(5|2|1|B)	{C1} Rser = {RserC1}
C35	(5|3|1|A)	(5|3|1|B)	{C1} Rser = {RserC1}
C36	(5|4|1|A)	(5|4|1|B)	{C1} Rser = {RserC1}
C37	(5|5|1|A)	(5|5|1|B)	{C1} Rser = {RserC1}
C38	(5|6|1|A)	(5|6|1|B)	{C1} Rser = {RserC1}
C39	(5|7|1|A)	(5|7|1|B)	{C1} Rser = {RserC1}
C40	(5|8|1|A)	(5|8|1|B)	{C1} Rser = {RserC1}
C41	(6|1|1|A)	(6|1|1|B)	{C1} Rser = {RserC1}
C42	(6|2|1|A)	(6|2|1|B)	{C1} Rser = {RserC1}
C43	(6|3|1|A)	(6|3|1|B)	{C1} Rser = {RserC1}
C44	(6|4|1|A)	(6|4|1|B)	{C1} Rser = {RserC1}
C45	(6|5|1|A)	(6|5|1|B)	{C1} Rser = {RserC1}
C46	(6|6|1|A)	(6|6|1|B)	{C1} Rser = {RserC1}
C47	(6|7|1|A)	(6|7|1|B)	{C1} Rser = {RserC1}
C48	(6|8|1|A)	(6|8|1|B)	{C1} Rser = {RserC1}
C49	(7|1|1|A)	(7|1|1|B)	{C1} Rser = {RserC1}
C50	(7|2|1|A)	(7|2|1|B)	{C1} Rser = {RserC1}
C51	(7|3|1|A)	(7|3|1|B)	{C1} Rser = {RserC1}
C52	(7|4|1|A)	(7|4|1|B)	{C1} Rser = {RserC1}
C53	(7|5|1|A)	(7|5|1|B)	{C1} Rser = {RserC1}
C54	(7|6|1|A)	(7|6|1|B)	{C1} Rser = {RserC1}
C55	(7|7|1|A)	(7|7|1|B)	{C1} Rser = {RserC1}
C56	(7|8|1|A)	(7|8|1|B)	{C1} Rser = {RserC1}
C57	(8|1|1|A)	(8|1|1|B)	{C1} Rser = {RserC1}
C58	(8|2|1|A)	(8|2|1|B)	{C1} Rser = {RserC1}
C59	(8|3|1|A)	(8|3|1|B)	{C1} Rser = {RserC1}
C60	(8|4|1|A)	(8|4|1|B)	{C1} Rser = {RserC1}
C61	(8|5|1|A)	(8|5|1|B)	{C1} Rser = {RserC1}
C62	(8|6|1|A)	(8|6|1|B)	{C1} Rser = {RserC1}
C63	(8|7|1|A)	(8|7|1|B)	{C1} Rser = {RserC1}
C64	(8|8|1|A)	(8|8|1|B)	{C1} Rser = {RserC1}
C65	(1|1|1|B)	(2|8|1|A)	{C2} Rser = {RserC2}
C66	(1|2|1|B)	(2|1|1|A)	{C2} Rser = {RserC2}
C67	(1|3|1|B)	(2|2|1|A)	{C2} Rser = {RserC2}
C68	(1|4|1|B)	(2|3|1|A)	{C2} Rser = {RserC2}
C69	(1|5|1|B)	(2|4|1|A)	{C2} Rser = {RserC2}
C70	(1|6|1|B)	(2|5|1|A)	{C2} Rser = {RserC2}
C71	(1|7|1|B)	(2|6|1|A)	{C2} Rser = {RserC2}
C72	(1|8|1|B)	(2|7|1|A)	{C2} Rser = {RserC2}
C73	(2|1|1|B)	(3|8|1|A)	{C2} Rser = {RserC2}
C74	(2|2|1|B)	(3|1|1|A)	{C2} Rser = {RserC2}
C75	(2|3|1|B)	(3|2|1|A)	{C2} Rser = {RserC2}
C76	(2|4|1|B)	(3|3|1|A)	{C2} Rser = {RserC2}
C77	(2|5|1|B)	(3|4|1|A)	{C2} Rser = {RserC2}
C78	(2|6|1|B)	(3|5|1|A)	{C2} Rser = {RserC2}
C79	(2|7|1|B)	(3|6|1|A)	{C2} Rser = {RserC2}
C80	(2|8|1|B)	(3|7|1|A)	{C2} Rser = {RserC2}
C81	(3|1|1|B)	(4|8|1|A)	{C2} Rser = {RserC2}
C82	(3|2|1|B)	(4|1|1|A)	{C2} Rser = {RserC2}
C83	(3|3|1|B)	(4|2|1|A)	{C2} Rser = {RserC2}
C84	(3|4|1|B)	(4|3|1|A)	{C2} Rser = {RserC2}
C85	(3|5|1|B)	(4|4|1|A)	{C2} Rser = {RserC2}
C86	(3|6|1|B)	(4|5|1|A)	{C2} Rser = {RserC2}
C87	(3|7|1|B)	(4|6|1|A)	{C2} Rser = {RserC2}
C88	(3|8|1|B)	(4|7|1|A)	{C2} Rser = {RserC2}
C89	(4|1|1|B)	(5|8|1|A)	{C2} Rser = {RserC2}
C90	(4|2|1|B)	(5|1|1|A)	{C2} Rser = {RserC2}
C91	(4|3|1|B)	(5|2|1|A)	{C2} Rser = {RserC2}
C92	(4|4|1|B)	(5|3|1|A)	{C2} Rser = {RserC2}
C93	(4|5|1|B)	(5|4|1|A)	{C2} Rser = {RserC2}
C94	(4|6|1|B)	(5|5|1|A)	{C2} Rser = {RserC2}
C95	(4|7|1|B)	(5|6|1|A)	{C2} Rser = {RserC2}
C96	(4|8|1|B)	(5|7|1|A)	{C2} Rser = {RserC2}
C97	(5|1|1|B)	(6|8|1|A)	{C2} Rser = {RserC2}
C98	(5|2|1|B)	(6|1|1|A)	{C2} Rser = {RserC2}
C99	(5|3|1|B)	(6|2|1|A)	{C2} Rser = {RserC2}
C100	(5|4|1|B)	(6|3|1|A)	{C2} Rser = {RserC2}
C101	(5|5|1|B)	(6|4|1|A)	{C2} Rser = {RserC2}
C102	(5|6|1|B)	(6|5|1|A)	{C2} Rser = {RserC2}
C103	(5|7|1|B)	(6|6|1|A)	{C2} Rser = {RserC2}
C104	(5|8|1|B)	(6|7|1|A)	{C2} Rser = {RserC2}
C105	(6|1|1|B)	(7|8|1|A)	{C2} Rser = {RserC2}
C106	(6|2|1|B)	(7|1|1|A)	{C2} Rser = {RserC2}
C107	(6|3|1|B)	(7|2|1|A)	{C2} Rser = {RserC2}
C108	(6|4|1|B)	(7|3|1|A)	{C2} Rser = {RserC2}
C109	(6|5|1|B)	(7|4|1|A)	{C2} Rser = {RserC2}
C110	(6|6|1|B)	(7|5|1|A)	{C2} Rser = {RserC2}
C111	(6|7|1|B)	(7|6|1|A)	{C2} Rser = {RserC2}
C112	(6|8|1|B)	(7|7|1|A)	{C2} Rser = {RserC2}
C113	(7|1|1|B)	(8|8|1|A)	{C2} Rser = {RserC2}
C114	(7|2|1|B)	(8|1|1|A)	{C2} Rser = {RserC2}
C115	(7|3|1|B)	(8|2|1|A)	{C2} Rser = {RserC2}
C116	(7|4|1|B)	(8|3|1|A)	{C2} Rser = {RserC2}
C117	(7|5|1|B)	(8|4|1|A)	{C2} Rser = {RserC2}
C118	(7|6|1|B)	(8|5|1|A)	{C2} Rser = {RserC2}
C119	(7|7|1|B)	(8|6|1|A)	{C2} Rser = {RserC2}
C120	(7|8|1|B)	(8|7|1|A)	{C2} Rser = {RserC2}
C121	(8|1|1|B)	(1|8|1|A)	{C2} Rser = {RserC2}
C122	(8|2|1|B)	(1|1|1|A)	{C2} Rser = {RserC2}
C123	(8|3|1|B)	(1|2|1|A)	{C2} Rser = {RserC2}
C124	(8|4|1|B)	(1|3|1|A)	{C2} Rser = {RserC2}
C125	(8|5|1|B)	(1|4|1|A)	{C2} Rser = {RserC2}
C126	(8|6|1|B)	(1|5|1|A)	{C2} Rser = {RserC2}
C127	(8|7|1|B)	(1|6|1|A)	{C2} Rser = {RserC2}
C128	(8|8|1|B)	(1|7|1|A)	{C2} Rser = {RserC2}
C129	(1|1|1|B)	(8|2|1|A)	{C2} Rser = {RserC2}
C130	(1|2|1|B)	(8|3|1|A)	{C2} Rser = {RserC2}
C131	(1|3|1|B)	(8|4|1|A)	{C2} Rser = {RserC2}
C132	(1|4|1|B)	(8|5|1|A)	{C2} Rser = {RserC2}
C133	(1|5|1|B)	(8|6|1|A)	{C2} Rser = {RserC2}
C134	(1|6|1|B)	(8|7|1|A)	{C2} Rser = {RserC2}
C135	(1|7|1|B)	(8|8|1|A)	{C2} Rser = {RserC2}
C136	(1|8|1|B)	(8|1|1|A)	{C2} Rser = {RserC2}
C137	(2|1|1|B)	(1|2|1|A)	{C2} Rser = {RserC2}
C138	(2|2|1|B)	(1|3|1|A)	{C2} Rser = {RserC2}
C139	(2|3|1|B)	(1|4|1|A)	{C2} Rser = {RserC2}
C140	(2|4|1|B)	(1|5|1|A)	{C2} Rser = {RserC2}
C141	(2|5|1|B)	(1|6|1|A)	{C2} Rser = {RserC2}
C142	(2|6|1|B)	(1|7|1|A)	{C2} Rser = {RserC2}
C143	(2|7|1|B)	(1|8|1|A)	{C2} Rser = {RserC2}
C144	(2|8|1|B)	(1|1|1|A)	{C2} Rser = {RserC2}
C145	(3|1|1|B)	(2|2|1|A)	{C2} Rser = {RserC2}
C146	(3|2|1|B)	(2|3|1|A)	{C2} Rser = {RserC2}
C147	(3|3|1|B)	(2|4|1|A)	{C2} Rser = {RserC2}
C148	(3|4|1|B)	(2|5|1|A)	{C2} Rser = {RserC2}
C149	(3|5|1|B)	(2|6|1|A)	{C2} Rser = {RserC2}
C150	(3|6|1|B)	(2|7|1|A)	{C2} Rser = {RserC2}
C151	(3|7|1|B)	(2|8|1|A)	{C2} Rser = {RserC2}
C152	(3|8|1|B)	(2|1|1|A)	{C2} Rser = {RserC2}
C153	(4|1|1|B)	(3|2|1|A)	{C2} Rser = {RserC2}
C154	(4|2|1|B)	(3|3|1|A)	{C2} Rser = {RserC2}
C155	(4|3|1|B)	(3|4|1|A)	{C2} Rser = {RserC2}
C156	(4|4|1|B)	(3|5|1|A)	{C2} Rser = {RserC2}
C157	(4|5|1|B)	(3|6|1|A)	{C2} Rser = {RserC2}
C158	(4|6|1|B)	(3|7|1|A)	{C2} Rser = {RserC2}
C159	(4|7|1|B)	(3|8|1|A)	{C2} Rser = {RserC2}
C160	(4|8|1|B)	(3|1|1|A)	{C2} Rser = {RserC2}
C161	(5|1|1|B)	(4|2|1|A)	{C2} Rser = {RserC2}
C162	(5|2|1|B)	(4|3|1|A)	{C2} Rser = {RserC2}
C163	(5|3|1|B)	(4|4|1|A)	{C2} Rser = {RserC2}
C164	(5|4|1|B)	(4|5|1|A)	{C2} Rser = {RserC2}
C165	(5|5|1|B)	(4|6|1|A)	{C2} Rser = {RserC2}
C166	(5|6|1|B)	(4|7|1|A)	{C2} Rser = {RserC2}
C167	(5|7|1|B)	(4|8|1|A)	{C2} Rser = {RserC2}
C168	(5|8|1|B)	(4|1|1|A)	{C2} Rser = {RserC2}
C169	(6|1|1|B)	(5|2|1|A)	{C2} Rser = {RserC2}
C170	(6|2|1|B)	(5|3|1|A)	{C2} Rser = {RserC2}
C171	(6|3|1|B)	(5|4|1|A)	{C2} Rser = {RserC2}
C172	(6|4|1|B)	(5|5|1|A)	{C2} Rser = {RserC2}
C173	(6|5|1|B)	(5|6|1|A)	{C2} Rser = {RserC2}
C174	(6|6|1|B)	(5|7|1|A)	{C2} Rser = {RserC2}
C175	(6|7|1|B)	(5|8|1|A)	{C2} Rser = {RserC2}
C176	(6|8|1|B)	(5|1|1|A)	{C2} Rser = {RserC2}
C177	(7|1|1|B)	(6|2|1|A)	{C2} Rser = {RserC2}
C178	(7|2|1|B)	(6|3|1|A)	{C2} Rser = {RserC2}
C179	(7|3|1|B)	(6|4|1|A)	{C2} Rser = {RserC2}
C180	(7|4|1|B)	(6|5|1|A)	{C2} Rser = {RserC2}
C181	(7|5|1|B)	(6|6|1|A)	{C2} Rser = {RserC2}
C182	(7|6|1|B)	(6|7|1|A)	{C2} Rser = {RserC2}
C183	(7|7|1|B)	(6|8|1|A)	{C2} Rser = {RserC2}
C184	(7|8|1|B)	(6|1|1|A)	{C2} Rser = {RserC2}
C185	(8|1|1|B)	(7|2|1|A)	{C2} Rser = {RserC2}
C186	(8|2|1|B)	(7|3|1|A)	{C2} Rser = {RserC2}
C187	(8|3|1|B)	(7|4|1|A)	{C2} Rser = {RserC2}
C188	(8|4|1|B)	(7|5|1|A)	{C2} Rser = {RserC2}
C189	(8|5|1|B)	(7|6|1|A)	{C2} Rser = {RserC2}
C190	(8|6|1|B)	(7|7|1|A)	{C2} Rser = {RserC2}
C191	(8|7|1|B)	(7|8|1|A)	{C2} Rser = {RserC2}
C192	(8|8|1|B)	(7|1|1|A)	{C2} Rser = {RserC2}
C193	(1|1|1|A)	(1|2|1|A)	{C3} Rser = {RserC3}
C194	(1|2|1|A)	(1|3|1|A)	{C3} Rser = {RserC3}
C195	(1|3|1|A)	(1|4|1|A)	{C3} Rser = {RserC3}
C196	(1|4|1|A)	(1|5|1|A)	{C3} Rser = {RserC3}
C197	(1|5|1|A)	(1|6|1|A)	{C3} Rser = {RserC3}
C198	(1|6|1|A)	(1|7|1|A)	{C3} Rser = {RserC3}
C199	(1|7|1|A)	(1|8|1|A)	{C3} Rser = {RserC3}
C200	(1|8|1|A)	(1|1|1|A)	{C3} Rser = {RserC3}
C201	(2|1|1|A)	(2|2|1|A)	{C3} Rser = {RserC3}
C202	(2|2|1|A)	(2|3|1|A)	{C3} Rser = {RserC3}
C203	(2|3|1|A)	(2|4|1|A)	{C3} Rser = {RserC3}
C204	(2|4|1|A)	(2|5|1|A)	{C3} Rser = {RserC3}
C205	(2|5|1|A)	(2|6|1|A)	{C3} Rser = {RserC3}
C206	(2|6|1|A)	(2|7|1|A)	{C3} Rser = {RserC3}
C207	(2|7|1|A)	(2|8|1|A)	{C3} Rser = {RserC3}
C208	(2|8|1|A)	(2|1|1|A)	{C3} Rser = {RserC3}
C209	(3|1|1|A)	(3|2|1|A)	{C3} Rser = {RserC3}
C210	(3|2|1|A)	(3|3|1|A)	{C3} Rser = {RserC3}
C211	(3|3|1|A)	(3|4|1|A)	{C3} Rser = {RserC3}
C212	(3|4|1|A)	(3|5|1|A)	{C3} Rser = {RserC3}
C213	(3|5|1|A)	(3|6|1|A)	{C3} Rser = {RserC3}
C214	(3|6|1|A)	(3|7|1|A)	{C3} Rser = {RserC3}
C215	(3|7|1|A)	(3|8|1|A)	{C3} Rser = {RserC3}
C216	(3|8|1|A)	(3|1|1|A)	{C3} Rser = {RserC3}
C217	(4|1|1|A)	(4|2|1|A)	{C3} Rser = {RserC3}
C218	(4|2|1|A)	(4|3|1|A)	{C3} Rser = {RserC3}
C219	(4|3|1|A)	(4|4|1|A)	{C3} Rser = {RserC3}
C220	(4|4|1|A)	(4|5|1|A)	{C3} Rser = {RserC3}
C221	(4|5|1|A)	(4|6|1|A)	{C3} Rser = {RserC3}
C222	(4|6|1|A)	(4|7|1|A)	{C3} Rser = {RserC3}
C223	(4|7|1|A)	(4|8|1|A)	{C3} Rser = {RserC3}
C224	(4|8|1|A)	(4|1|1|A)	{C3} Rser = {RserC3}
C225	(5|1|1|A)	(5|2|1|A)	{C3} Rser = {RserC3}
C226	(5|2|1|A)	(5|3|1|A)	{C3} Rser = {RserC3}
C227	(5|3|1|A)	(5|4|1|A)	{C3} Rser = {RserC3}
C228	(5|4|1|A)	(5|5|1|A)	{C3} Rser = {RserC3}
C229	(5|5|1|A)	(5|6|1|A)	{C3} Rser = {RserC3}
C230	(5|6|1|A)	(5|7|1|A)	{C3} Rser = {RserC3}
C231	(5|7|1|A)	(5|8|1|A)	{C3} Rser = {RserC3}
C232	(5|8|1|A)	(5|1|1|A)	{C3} Rser = {RserC3}
C233	(6|1|1|A)	(6|2|1|A)	{C3} Rser = {RserC3}
C234	(6|2|1|A)	(6|3|1|A)	{C3} Rser = {RserC3}
C235	(6|3|1|A)	(6|4|1|A)	{C3} Rser = {RserC3}
C236	(6|4|1|A)	(6|5|1|A)	{C3} Rser = {RserC3}
C237	(6|5|1|A)	(6|6|1|A)	{C3} Rser = {RserC3}
C238	(6|6|1|A)	(6|7|1|A)	{C3} Rser = {RserC3}
C239	(6|7|1|A)	(6|8|1|A)	{C3} Rser = {RserC3}
C240	(6|8|1|A)	(6|1|1|A)	{C3} Rser = {RserC3}
C241	(7|1|1|A)	(7|2|1|A)	{C3} Rser = {RserC3}
C242	(7|2|1|A)	(7|3|1|A)	{C3} Rser = {RserC3}
C243	(7|3|1|A)	(7|4|1|A)	{C3} Rser = {RserC3}
C244	(7|4|1|A)	(7|5|1|A)	{C3} Rser = {RserC3}
C245	(7|5|1|A)	(7|6|1|A)	{C3} Rser = {RserC3}
C246	(7|6|1|A)	(7|7|1|A)	{C3} Rser = {RserC3}
C247	(7|7|1|A)	(7|8|1|A)	{C3} Rser = {RserC3}
C248	(7|8|1|A)	(7|1|1|A)	{C3} Rser = {RserC3}
C249	(8|1|1|A)	(8|2|1|A)	{C3} Rser = {RserC3}
C250	(8|2|1|A)	(8|3|1|A)	{C3} Rser = {RserC3}
C251	(8|3|1|A)	(8|4|1|A)	{C3} Rser = {RserC3}
C252	(8|4|1|A)	(8|5|1|A)	{C3} Rser = {RserC3}
C253	(8|5|1|A)	(8|6|1|A)	{C3} Rser = {RserC3}
C254	(8|6|1|A)	(8|7|1|A)	{C3} Rser = {RserC3}
C255	(8|7|1|A)	(8|8|1|A)	{C3} Rser = {RserC3}
C256	(8|8|1|A)	(8|1|1|A)	{C3} Rser = {RserC3}
L1	(1|1|1|B)	(1|2|1|B)	{L1} Rser = {RserL1}
L2	(1|2|1|B)	(1|3|1|B)	{L1} Rser = {RserL1}
L3	(1|3|1|B)	(1|4|1|B)	{L1} Rser = {RserL1}
L4	(1|4|1|B)	(1|5|1|B)	{L1} Rser = {RserL1}
L5	(1|5|1|B)	(1|6|1|B)	{L1} Rser = {RserL1}
L6	(1|6|1|B)	(1|7|1|B)	{L1} Rser = {RserL1}
L7	(1|7|1|B)	(1|8|1|B)	{L1} Rser = {RserL1}
L8	(1|8|1|B)	(1|1|1|B)	{L1} Rser = {RserL1}
L9	(2|1|1|B)	(2|2|1|B)	{L1} Rser = {RserL1}
L10	(2|2|1|B)	(2|3|1|B)	{L1} Rser = {RserL1}
L11	(2|3|1|B)	(2|4|1|B)	{L1} Rser = {RserL1}
L12	(2|4|1|B)	(2|5|1|B)	{L1} Rser = {RserL1}
L13	(2|5|1|B)	(2|6|1|B)	{L1} Rser = {RserL1}
L14	(2|6|1|B)	(2|7|1|B)	{L1} Rser = {RserL1}
L15	(2|7|1|B)	(2|8|1|B)	{L1} Rser = {RserL1}
L16	(2|8|1|B)	(2|1|1|B)	{L1} Rser = {RserL1}
L17	(3|1|1|B)	(3|2|1|B)	{L1} Rser = {RserL1}
L18	(3|2|1|B)	(3|3|1|B)	{L1} Rser = {RserL1}
L19	(3|3|1|B)	(3|4|1|B)	{L1} Rser = {RserL1}
L20	(3|4|1|B)	(3|5|1|B)	{L1} Rser = {RserL1}
L21	(3|5|1|B)	(3|6|1|B)	{L1} Rser = {RserL1}
L22	(3|6|1|B)	(3|7|1|B)	{L1} Rser = {RserL1}
L23	(3|7|1|B)	(3|8|1|B)	{L1} Rser = {RserL1}
L24	(3|8|1|B)	(3|1|1|B)	{L1} Rser = {RserL1}
L25	(4|1|1|B)	(4|2|1|B)	{L1} Rser = {RserL1}
L26	(4|2|1|B)	(4|3|1|B)	{L1} Rser = {RserL1}
L27	(4|3|1|B)	(4|4|1|B)	{L1} Rser = {RserL1}
L28	(4|4|1|B)	(4|5|1|B)	{L1} Rser = {RserL1}
L29	(4|5|1|B)	(4|6|1|B)	{L1} Rser = {RserL1}
L30	(4|6|1|B)	(4|7|1|B)	{L1} Rser = {RserL1}
L31	(4|7|1|B)	(4|8|1|B)	{L1} Rser = {RserL1}
L32	(4|8|1|B)	(4|1|1|B)	{L1} Rser = {RserL1}
L33	(5|1|1|B)	(5|2|1|B)	{L1} Rser = {RserL1}
L34	(5|2|1|B)	(5|3|1|B)	{L1} Rser = {RserL1}
L35	(5|3|1|B)	(5|4|1|B)	{L1} Rser = {RserL1}
L36	(5|4|1|B)	(5|5|1|B)	{L1} Rser = {RserL1}
L37	(5|5|1|B)	(5|6|1|B)	{L1} Rser = {RserL1}
L38	(5|6|1|B)	(5|7|1|B)	{L1} Rser = {RserL1}
L39	(5|7|1|B)	(5|8|1|B)	{L1} Rser = {RserL1}
L40	(5|8|1|B)	(5|1|1|B)	{L1} Rser = {RserL1}
L41	(6|1|1|B)	(6|2|1|B)	{L1} Rser = {RserL1}
L42	(6|2|1|B)	(6|3|1|B)	{L1} Rser = {RserL1}
L43	(6|3|1|B)	(6|4|1|B)	{L1} Rser = {RserL1}
L44	(6|4|1|B)	(6|5|1|B)	{L1} Rser = {RserL1}
L45	(6|5|1|B)	(6|6|1|B)	{L1} Rser = {RserL1}
L46	(6|6|1|B)	(6|7|1|B)	{L1} Rser = {RserL1}
L47	(6|7|1|B)	(6|8|1|B)	{L1} Rser = {RserL1}
L48	(6|8|1|B)	(6|1|1|B)	{L1} Rser = {RserL1}
L49	(7|1|1|B)	(7|2|1|B)	{L1} Rser = {RserL1}
L50	(7|2|1|B)	(7|3|1|B)	{L1} Rser = {RserL1}
L51	(7|3|1|B)	(7|4|1|B)	{L1} Rser = {RserL1}
L52	(7|4|1|B)	(7|5|1|B)	{L1} Rser = {RserL1}
L53	(7|5|1|B)	(7|6|1|B)	{L1} Rser = {RserL1}
L54	(7|6|1|B)	(7|7|1|B)	{L1} Rser = {RserL1}
L55	(7|7|1|B)	(7|8|1|B)	{L1} Rser = {RserL1}
L56	(7|8|1|B)	(7|1|1|B)	{L1} Rser = {RserL1}
L57	(8|1|1|B)	(8|2|1|B)	{L1} Rser = {RserL1}
L58	(8|2|1|B)	(8|3|1|B)	{L1} Rser = {RserL1}
L59	(8|3|1|B)	(8|4|1|B)	{L1} Rser = {RserL1}
L60	(8|4|1|B)	(8|5|1|B)	{L1} Rser = {RserL1}
L61	(8|5|1|B)	(8|6|1|B)	{L1} Rser = {RserL1}
L62	(8|6|1|B)	(8|7|1|B)	{L1} Rser = {RserL1}
L63	(8|7|1|B)	(8|8|1|B)	{L1} Rser = {RserL1}
L64	(8|8|1|B)	(8|1|1|B)	{L1} Rser = {RserL1}
R1	(1|1|1|A)	(2|1|1|A)	{R1}
R2	(1|2|1|A)	(2|2|1|A)	{R1}
R3	(1|3|1|A)	(2|3|1|A)	{R1}
R4	(1|4|1|A)	(2|4|1|A)	{R1}
R5	(1|5|1|A)	(2|5|1|A)	{R1}
R6	(1|6|1|A)	(2|6|1|A)	{R1}
R7	(1|7|1|A)	(2|7|1|A)	{R1}
R8	(1|8|1|A)	(2|8|1|A)	{R1}
R9	(2|1|1|A)	(3|1|1|A)	{R1}
R10	(2|2|1|A)	(3|2|1|A)	{R1}
R11	(2|3|1|A)	(3|3|1|A)	{R1}
R12	(2|4|1|A)	(3|4|1|A)	{R1}
R13	(2|5|1|A)	(3|5|1|A)	{R1}
R14	(2|6|1|A)	(3|6|1|A)	{R1}
R15	(2|7|1|A)	(3|7|1|A)	{R1}
R16	(2|8|1|A)	(3|8|1|A)	{R1}
R17	(3|1|1|A)	(4|1|1|A)	{R1}
R18	(3|2|1|A)	(4|2|1|A)	{R1}
R19	(3|3|1|A)	(4|3|1|A)	{R1}
R20	(3|4|1|A)	(4|4|1|A)	{R1}
R21	(3|5|1|A)	(4|5|1|A)	{R1}
R22	(3|6|1|A)	(4|6|1|A)	{R1}
R23	(3|7|1|A)	(4|7|1|A)	{R1}
R24	(3|8|1|A)	(4|8|1|A)	{R1}
R25	(4|1|1|A)	(5|1|1|A)	{R1}
R26	(4|2|1|A)	(5|2|1|A)	{R1}
R27	(4|3|1|A)	(5|3|1|A)	{R1}
R28	(4|4|1|A)	(5|4|1|A)	{R1}
R29	(4|5|1|A)	(5|5|1|A)	{R1}
R30	(4|6|1|A)	(5|6|1|A)	{R1}
R31	(4|7|1|A)	(5|7|1|A)	{R1}
R32	(4|8|1|A)	(5|8|1|A)	{R1}
R33	(5|1|1|A)	(6|1|1|A)	{R1}
R34	(5|2|1|A)	(6|2|1|A)	{R1}
R35	(5|3|1|A)	(6|3|1|A)	{R1}
R36	(5|4|1|A)	(6|4|1|A)	{R1}
R37	(5|5|1|A)	(6|5|1|A)	{R1}
R38	(5|6|1|A)	(6|6|1|A)	{R1}
R39	(5|7|1|A)	(6|7|1|A)	{R1}
R40	(5|8|1|A)	(6|8|1|A)	{R1}
R41	(6|1|1|A)	(7|1|1|A)	{R1}
R42	(6|2|1|A)	(7|2|1|A)	{R1}
R43	(6|3|1|A)	(7|3|1|A)	{R1}
R44	(6|4|1|A)	(7|4|1|A)	{R1}
R45	(6|5|1|A)	(7|5|1|A)	{R1}
R46	(6|6|1|A)	(7|6|1|A)	{R1}
R47	(6|7|1|A)	(7|7|1|A)	{R1}
R48	(6|8|1|A)	(7|8|1|A)	{R1}
R49	(7|1|1|A)	(8|1|1|A)	{R1}
R50	(7|2|1|A)	(8|2|1|A)	{R1}
R51	(7|3|1|A)	(8|3|1|A)	{R1}
R52	(7|4|1|A)	(8|4|1|A)	{R1}
R53	(7|5|1|A)	(8|5|1|A)	{R1}
R54	(7|6|1|A)	(8|6|1|A)	{R1}
R55	(7|7|1|A)	(8|7|1|A)	{R1}
R56	(7|8|1|A)	(8|8|1|A)	{R1}
R57	(8|1|1|A)	(1|1|1|A)	{R1}
R58	(8|2|1|A)	(1|2|1|A)	{R1}
R59	(8|3|1|A)	(1|3|1|A)	{R1}
R60	(8|4|1|A)	(1|4|1|A)	{R1}
R61	(8|5|1|A)	(1|5|1|A)	{R1}
R62	(8|6|1|A)	(1|6|1|A)	{R1}
R63	(8|7|1|A)	(1|7|1|A)	{R1}
R64	(8|8|1|A)	(1|8|1|A)	{R1}
R65	(1|1|1|B)	(2|1|1|B)	{R1}
R66	(1|2|1|B)	(2|2|1|B)	{R1}
R67	(1|3|1|B)	(2|3|1|B)	{R1}
R68	(1|4|1|B)	(2|4|1|B)	{R1}
R69	(1|5|1|B)	(2|5|1|B)	{R1}
R70	(1|6|1|B)	(2|6|1|B)	{R1}
R71	(1|7|1|B)	(2|7|1|B)	{R1}
R72	(1|8|1|B)	(2|8|1|B)	{R1}
R73	(2|1|1|B)	(3|1|1|B)	{R1}
R74	(2|2|1|B)	(3|2|1|B)	{R1}
R75	(2|3|1|B)	(3|3|1|B)	{R1}
R76	(2|4|1|B)	(3|4|1|B)	{R1}
R77	(2|5|1|B)	(3|5|1|B)	{R1}
R78	(2|6|1|B)	(3|6|1|B)	{R1}
R79	(2|7|1|B)	(3|7|1|B)	{R1}
R80	(2|8|1|B)	(3|8|1|B)	{R1}
R81	(3|1|1|B)	(4|1|1|B)	{R1}
R82	(3|2|1|B)	(4|2|1|B)	{R1}
R83	(3|3|1|B)	(4|3|1|B)	{R1}
R84	(3|4|1|B)	(4|4|1|B)	{R1}
R85	(3|5|1|B)	(4|5|1|B)	{R1}
R86	(3|6|1|B)	(4|6|1|B)	{R1}
R87	(3|7|1|B)	(4|7|1|B)	{R1}
R88	(3|8|1|B)	(4|8|1|B)	{R1}
R89	(4|1|1|B)	(5|1|1|B)	{R1}
R90	(4|2|1|B)	(5|2|1|B)	{R1}
R91	(4|3|1|B)	(5|3|1|B)	{R1}
R92	(4|4|1|B)	(5|4|1|B)	{R1}
R93	(4|5|1|B)	(5|5|1|B)	{R1}
R94	(4|6|1|B)	(5|6|1|B)	{R1}
R95	(4|7|1|B)	(5|7|1|B)	{R1}
R96	(4|8|1|B)	(5|8|1|B)	{R1}
R97	(5|1|1|B)	(6|1|1|B)	{R1}
R98	(5|2|1|B)	(6|2|1|B)	{R1}
R99	(5|3|1|B)	(6|3|1|B)	{R1}
R100	(5|4|1|B)	(6|4|1|B)	{R1}
R101	(5|5|1|B)	(6|5|1|B)	{R1}
R102	(5|6|1|B)	(6|6|1|B)	{R1}
R103	(5|7|1|B)	(6|7|1|B)	{R1}
R104	(5|8|1|B)	(6|8|1|B)	{R1}
R105	(6|1|1|B)	(7|1|1|B)	{R1}
R106	(6|2|1|B)	(7|2|1|B)	{R1}
R107	(6|3|1|B)	(7|3|1|B)	{R1}
R108	(6|4|1|B)	(7|4|1|B)	{R1}
R109	(6|5|1|B)	(7|5|1|B)	{R1}
R110	(6|6|1|B)	(7|6|1|B)	{R1}
R111	(6|7|1|B)	(7|7|1|B)	{R1}
R112	(6|8|1|B)	(7|8|1|B)	{R1}
R113	(7|1|1|B)	(8|1|1|B)	{R1}
R114	(7|2|1|B)	(8|2|1|B)	{R1}
R115	(7|3|1|B)	(8|3|1|B)	{R1}
R116	(7|4|1|B)	(8|4|1|B)	{R1}
R117	(7|5|1|B)	(8|5|1|B)	{R1}
R118	(7|6|1|B)	(8|6|1|B)	{R1}
R119	(7|7|1|B)	(8|7|1|B)	{R1}
R120	(7|8|1|B)	(8|8|1|B)	{R1}
R121	(8|1|1|B)	(1|1|1|B)	{R1}
R122	(8|2|1|B)	(1|2|1|B)	{R1}
R123	(8|3|1|B)	(1|3|1|B)	{R1}
R124	(8|4|1|B)	(1|4|1|B)	{R1}
R125	(8|5|1|B)	(1|5|1|B)	{R1}
R126	(8|6|1|B)	(1|6|1|B)	{R1}
R127	(8|7|1|B)	(1|7|1|B)	{R1}
R128	(8|8|1|B)	(1|8|1|B)	{R1}
L65	(1|1|1|A)	0		{L2} Rser = {RserL2}
L66	(1|2|1|A)	0		{L2} Rser = {RserL2}
L67	(1|3|1|A)	0		{L2} Rser = {RserL2}
L68	(1|4|1|A)	0		{L2} Rser = {RserL2}
L69	(1|5|1|A)	0		{L2} Rser = {RserL2}
L70	(1|6|1|A)	0		{L2} Rser = {RserL2}
L71	(1|7|1|A)	0		{L2} Rser = {RserL2}
L72	(1|8|1|A)	0		{L2} Rser = {RserL2}
L73	(2|1|1|A)	0		{L2} Rser = {RserL2}
L74	(2|2|1|A)	0		{L2} Rser = {RserL2}
L75	(2|3|1|A)	0		{L2} Rser = {RserL2}
L76	(2|4|1|A)	0		{L2} Rser = {RserL2}
L77	(2|5|1|A)	0		{L2} Rser = {RserL2}
L78	(2|6|1|A)	0		{L2} Rser = {RserL2}
L79	(2|7|1|A)	0		{L2} Rser = {RserL2}
L80	(2|8|1|A)	0		{L2} Rser = {RserL2}
L81	(3|1|1|A)	0		{L2} Rser = {RserL2}
L82	(3|2|1|A)	0		{L2} Rser = {RserL2}
L83	(3|3|1|A)	0		{L2} Rser = {RserL2}
L84	(3|4|1|A)	0		{L2} Rser = {RserL2}
L85	(3|5|1|A)	0		{L2} Rser = {RserL2}
L86	(3|6|1|A)	0		{L2} Rser = {RserL2}
L87	(3|7|1|A)	0		{L2} Rser = {RserL2}
L88	(3|8|1|A)	0		{L2} Rser = {RserL2}
L89	(4|1|1|A)	0		{L2} Rser = {RserL2}
L90	(4|2|1|A)	0		{L2} Rser = {RserL2}
L91	(4|3|1|A)	0		{L2} Rser = {RserL2}
L92	(4|4|1|A)	0		{L2} Rser = {RserL2}
L93	(4|5|1|A)	0		{L2} Rser = {RserL2}
L94	(4|6|1|A)	0		{L2} Rser = {RserL2}
L95	(4|7|1|A)	0		{L2} Rser = {RserL2}
L96	(4|8|1|A)	0		{L2} Rser = {RserL2}
L97	(5|1|1|A)	0		{L2} Rser = {RserL2}
L98	(5|2|1|A)	0		{L2} Rser = {RserL2}
L99	(5|3|1|A)	0		{L2} Rser = {RserL2}
L100	(5|4|1|A)	0		{L2} Rser = {RserL2}
L101	(5|5|1|A)	0		{L2} Rser = {RserL2}
L102	(5|6|1|A)	0		{L2} Rser = {RserL2}
L103	(5|7|1|A)	0		{L2} Rser = {RserL2}
L104	(5|8|1|A)	0		{L2} Rser = {RserL2}
L105	(6|1|1|A)	0		{L2} Rser = {RserL2}
L106	(6|2|1|A)	0		{L2} Rser = {RserL2}
L107	(6|3|1|A)	0		{L2} Rser = {RserL2}
L108	(6|4|1|A)	0		{L2} Rser = {RserL2}
L109	(6|5|1|A)	0		{L2} Rser = {RserL2}
L110	(6|6|1|A)	0		{L2} Rser = {RserL2}
L111	(6|7|1|A)	0		{L2} Rser = {RserL2}
L112	(6|8|1|A)	0		{L2} Rser = {RserL2}
L113	(7|1|1|A)	0		{L2} Rser = {RserL2}
L114	(7|2|1|A)	0		{L2} Rser = {RserL2}
L115	(7|3|1|A)	0		{L2} Rser = {RserL2}
L116	(7|4|1|A)	0		{L2} Rser = {RserL2}
L117	(7|5|1|A)	0		{L2} Rser = {RserL2}
L118	(7|6|1|A)	0		{L2} Rser = {RserL2}
L119	(7|7|1|A)	0		{L2} Rser = {RserL2}
L120	(7|8|1|A)	0		{L2} Rser = {RserL2}
L121	(8|1|1|A)	0		{L2} Rser = {RserL2}
L122	(8|2|1|A)	0		{L2} Rser = {RserL2}
L123	(8|3|1|A)	0		{L2} Rser = {RserL2}
L124	(8|4|1|A)	0		{L2} Rser = {RserL2}
L125	(8|5|1|A)	0		{L2} Rser = {RserL2}
L126	(8|6|1|A)	0		{L2} Rser = {RserL2}
L127	(8|7|1|A)	0		{L2} Rser = {RserL2}
L128	(8|8|1|A)	0		{L2} Rser = {RserL2}
L129	(1|1|1|B)	0		{L3} Rser = {RserL3}
L130	(1|2|1|B)	0		{L3} Rser = {RserL3}
L131	(1|3|1|B)	0		{L3} Rser = {RserL3}
L132	(1|4|1|B)	0		{L3} Rser = {RserL3}
L133	(1|5|1|B)	0		{L3} Rser = {RserL3}
L134	(1|6|1|B)	0		{L3} Rser = {RserL3}
L135	(1|7|1|B)	0		{L3} Rser = {RserL3}
L136	(1|8|1|B)	0		{L3} Rser = {RserL3}
L137	(2|1|1|B)	0		{L3} Rser = {RserL3}
L138	(2|2|1|B)	0		{L3} Rser = {RserL3}
L139	(2|3|1|B)	0		{L3} Rser = {RserL3}
L140	(2|4|1|B)	0		{L3} Rser = {RserL3}
L141	(2|5|1|B)	0		{L3} Rser = {RserL3}
L142	(2|6|1|B)	0		{L3} Rser = {RserL3}
L143	(2|7|1|B)	0		{L3} Rser = {RserL3}
L144	(2|8|1|B)	0		{L3} Rser = {RserL3}
L145	(3|1|1|B)	0		{L3} Rser = {RserL3}
L146	(3|2|1|B)	0		{L3} Rser = {RserL3}
L147	(3|3|1|B)	0		{L3} Rser = {RserL3}
L148	(3|4|1|B)	0		{L3} Rser = {RserL3}
L149	(3|5|1|B)	0		{L3} Rser = {RserL3}
L150	(3|6|1|B)	0		{L3} Rser = {RserL3}
L151	(3|7|1|B)	0		{L3} Rser = {RserL3}
L152	(3|8|1|B)	0		{L3} Rser = {RserL3}
L153	(4|1|1|B)	0		{L3} Rser = {RserL3}
L154	(4|2|1|B)	0		{L3} Rser = {RserL3}
L155	(4|3|1|B)	0		{L3} Rser = {RserL3}
L156	(4|4|1|B)	0		{L3} Rser = {RserL3}
L157	(4|5|1|B)	0		{L3} Rser = {RserL3}
L158	(4|6|1|B)	0		{L3} Rser = {RserL3}
L159	(4|7|1|B)	0		{L3} Rser = {RserL3}
L160	(4|8|1|B)	0		{L3} Rser = {RserL3}
L161	(5|1|1|B)	0		{L3} Rser = {RserL3}
L162	(5|2|1|B)	0		{L3} Rser = {RserL3}
L163	(5|3|1|B)	0		{L3} Rser = {RserL3}
L164	(5|4|1|B)	0		{L3} Rser = {RserL3}
L165	(5|5|1|B)	0		{L3} Rser = {RserL3}
L166	(5|6|1|B)	0		{L3} Rser = {RserL3}
L167	(5|7|1|B)	0		{L3} Rser = {RserL3}
L168	(5|8|1|B)	0		{L3} Rser = {RserL3}
L169	(6|1|1|B)	0		{L3} Rser = {RserL3}
L170	(6|2|1|B)	0		{L3} Rser = {RserL3}
L171	(6|3|1|B)	0		{L3} Rser = {RserL3}
L172	(6|4|1|B)	0		{L3} Rser = {RserL3}
L173	(6|5|1|B)	0		{L3} Rser = {RserL3}
L174	(6|6|1|B)	0		{L3} Rser = {RserL3}
L175	(6|7|1|B)	0		{L3} Rser = {RserL3}
L176	(6|8|1|B)	0		{L3} Rser = {RserL3}
L177	(7|1|1|B)	0		{L3} Rser = {RserL3}
L178	(7|2|1|B)	0		{L3} Rser = {RserL3}
L179	(7|3|1|B)	0		{L3} Rser = {RserL3}
L180	(7|4|1|B)	0		{L3} Rser = {RserL3}
L181	(7|5|1|B)	0		{L3} Rser = {RserL3}
L182	(7|6|1|B)	0		{L3} Rser = {RserL3}
L183	(7|7|1|B)	0		{L3} Rser = {RserL3}
L184	(7|8|1|B)	0		{L3} Rser = {RserL3}
L185	(8|1|1|B)	0		{L3} Rser = {RserL3}
L186	(8|2|1|B)	0		{L3} Rser = {RserL3}
L187	(8|3|1|B)	0		{L3} Rser = {RserL3}
L188	(8|4|1|B)	0		{L3} Rser = {RserL3}
L189	(8|5|1|B)	0		{L3} Rser = {RserL3}
L190	(8|6|1|B)	0		{L3} Rser = {RserL3}
L191	(8|7|1|B)	0		{L3} Rser = {RserL3}
L192	(8|8|1|B)	0		{L3} Rser = {RserL3}
V1 vol1 0 AC 1
R129 vol1 (1|1|1|A) {Rvolt}
.param   C1 = 150p   RserC1 = 10m   C2 = 75p   RserC2 = 10m   C3 = 150p   RserC3 = 10m   L1 = 27u   RserL1 = 100m   R1 = 270   L2 = 5.6u   RserL2 = 100m   L3 = 27u   RserL3 = 100m
.param Rvolt = 50
.ac dec 100  100000  10000000
.save I(R129) V(1|1|1|A) V(1|1|1|B) V(2|1|1|A) V(2|1|1|B) V(3|1|1|A) V(3|1|1|B) V(4|1|1|A) V(4|1|1|B) V(5|1|1|A) V(5|1|1|B) V(6|1|1|A) V(6|1|1|B) V(7|1|1|A) V(7|1|1|B) V(8|1|1|A) V(8|1|1|B) V(1|2|1|A) V(1|2|1|B) V(2|2|1|A) V(2|2|1|B) V(3|2|1|A) V(3|2|1|B) V(4|2|1|A) V(4|2|1|B) V(5|2|1|A) V(5|2|1|B) V(6|2|1|A) V(6|2|1|B) V(7|2|1|A) V(7|2|1|B) V(8|2|1|A) V(8|2|1|B) V(1|3|1|A) V(1|3|1|B) V(2|3|1|A) V(2|3|1|B) V(3|3|1|A) V(3|3|1|B) V(4|3|1|A) V(4|3|1|B) V(5|3|1|A) V(5|3|1|B) V(6|3|1|A) V(6|3|1|B) V(7|3|1|A) V(7|3|1|B) V(8|3|1|A) V(8|3|1|B) V(1|4|1|A) V(1|4|1|B) V(2|4|1|A) V(2|4|1|B) V(3|4|1|A) V(3|4|1|B) V(4|4|1|A) V(4|4|1|B) V(5|4|1|A) V(5|4|1|B) V(6|4|1|A) V(6|4|1|B) V(7|4|1|A) V(7|4|1|B) V(8|4|1|A) V(8|4|1|B) V(1|5|1|A) V(1|5|1|B) V(2|5|1|A) V(2|5|1|B) V(3|5|1|A) V(3|5|1|B) V(4|5|1|A) V(4|5|1|B) V(5|5|1|A) V(5|5|1|B) V(6|5|1|A) V(6|5|1|B) V(7|5|1|A) V(7|5|1|B) V(8|5|1|A) V(8|5|1|B) V(1|6|1|A) V(1|6|1|B) V(2|6|1|A) V(2|6|1|B) V(3|6|1|A) V(3|6|1|B) V(4|6|1|A) V(4|6|1|B) V(5|6|1|A) V(5|6|1|B) V(6|6|1|A) V(6|6|1|B) V(7|6|1|A) V(7|6|1|B) V(8|6|1|A) V(8|6|1|B) V(1|7|1|A) V(1|7|1|B) V(2|7|1|A) V(2|7|1|B) V(3|7|1|A) V(3|7|1|B) V(4|7|1|A) V(4|7|1|B) V(5|7|1|A) V(5|7|1|B) V(6|7|1|A) V(6|7|1|B) V(7|7|1|A) V(7|7|1|B) V(8|7|1|A) V(8|7|1|B) V(1|8|1|A) V(1|8|1|B) V(2|8|1|A) V(2|8|1|B) V(3|8|1|A) V(3|8|1|B) V(4|8|1|A) V(4|8|1|B) V(5|8|1|A) V(5|8|1|B) V(6|8|1|A) V(6|8|1|B) V(7|8|1|A) V(7|8|1|B) V(8|8|1|A) V(8|8|1|B)
